# IAR project fire_adc_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\fire_adc_demo; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\mma; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\xw; ..\..\src\drivers\dma; ..\..\src\drivers\boma_key; ..\..\src\drivers\spi; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\CCD; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\fire_adc_demo; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\xw; ..\..\src\drivers\boma_key; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\spi; ..\..\src\drivers\dma; ..\..\src\drivers\CCD; ..\..\build
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group app
    ../../src/projects/fire_adc_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/boma_key/: boma_key.c
    ../../src/drivers/CCD/: calculation.c
    ../../src/drivers/xw/: carcontrol.c outputdata.c xw12864.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/mma/: mma8451.c
    ../../src/drivers/NRF24L0/: NRF24L0.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/spi/: spi.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/drivers/adc/: adc.h
    ../../src/drivers/CCD/: calculation.h
    ../../src/common/: common.h
    ../../src/drivers/dma/: dma.h
    ../../src/cpu/: dma_channels.h
    ../../src/drivers/FTM/: FTM.h
    ../../src/drivers/gpio/: gpio_cfg.h
    ../../src/LIB/CMSIS/: iar_cortexM4l_math.a
    ../../src/projects/fire_adc_demo/: include.h isr.h
    ../../src/platforms/: k60_fire.h
    ../../src/drivers/LED/: LED.H
    ../../src/drivers/mma/: mma8451.h
    ../../src/drivers/PIT/: PIT.h
