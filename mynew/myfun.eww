<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\adc_demo\fire_adc_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


